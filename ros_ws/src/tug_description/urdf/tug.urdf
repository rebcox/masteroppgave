Commit message: simulation ok, ex ship part

File: ros_ws/src/tug_description/urdf/tug.urdf (robot description, URDF)
Before this commit: robot simple_box, 1 links, 0 joints
Links:
- link my_box: geometry collision box size=0.5 0.5 2; visual box size=0.5 0.5 2
